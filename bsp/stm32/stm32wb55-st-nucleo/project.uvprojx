# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32WB55xx
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\libraries\STM32WBxx_HAL\STM32WBxx_HAL_Driver\Inc;..\libraries\STM32WBxx_HAL\CMSIS\Device\ST\STM32WBxx\Include;..\libraries\STM32WBxx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32wbxx_hal_msp.c
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/arm/: startup_stm32wb55xx_cm4.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_soft_i2c.c drv_adc.c drv_rtc.c drv_common.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
    ../libraries/STM32WBxx_HAL/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_gpio.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_usart.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_qspi.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c
